# Keil uVision project F4MouseRTThread_V1.0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4MouseRTThread_V1.0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE,RTE_USING_FINSH,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\PROJ;..\FWLIB\inc;..\CORE;..\OS\RT-Thread_include;..\OS\RT-Thread_include\libc;..\OS\RT-Thread_include\finsh;..\HARDWARE\inc;..\DSP_LIB\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    ../APP/: main.c
    ./: MouseDrive.c
  group Hardware
    ../HARDWARE/src/: MouseDrive_init.c usart_init.c SPI_init.c icm_20948.c
  group Project
    ./: board.c rtconfig.h stm32f4xx.h stm32f4xx_it.c stm32f4xx_it.h
    ../FWLIB/inc/: system_stm32f4xx.c
  group STDlibrary
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group RTT_libcpu
    ../OS/RT-Thread_libcpu/cortex-m4/: cpuport.c context_rvds.S
  group RTT_kernel
    ../OS/RT-Thread_src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Core
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group finsh
    ../OS/RT-Thread_include/finsh/: cmd.c msh.c shell.c
  group DSP_lib
    ../DSP_LIB/: arm_cortexM4lf_math.lib
